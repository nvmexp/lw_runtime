/*
 * LWIDIA_COPYRIGHT_BEGIN
 *
 * Copyright (c) 2008-2017, LWPU CORPORATION.  All rights reserved.
 *
 * LWPU CORPORATION and its licensors retain all intellectual property
 * and proprietary rights in and to this software, related documentation
 * and any modifications thereto.  Any use, reproduction, disclosure or
 * distribution of this software and related documentation without an express
 * license agreement from LWPU CORPORATION is strictly prohibited.
 *
 * LWIDIA_COPYRIGHT_END
 */
/*
 *  Module name              : stdObfuscate.c
 *
 *  Description              :
 *
 */


/*------------------------------- Includes -----------------------------------*/

#include "stdObfuscate.h"
#include "stdLocal.h"

/*------------------------------- Module State -------------------------------*/

static uInt8 permutation[] =
{
    0x44,0xd2,0x38,0x76,0x30,0xda,0xdf,0x8d,0xac,0x4c,0x95,0xa6,0xaf,0x02,0xe3,0xc1,
    0xdd,0x68,0x29,0x1d,0x99,0xf8,0x07,0x88,0x63,0x6f,0x9a,0x56,0xee,0xc6,0x03,0x71,
    0xca,0x78,0xdc,0xe1,0x83,0xbe,0xb4,0x64,0x0e,0x0a,0x69,0x2b,0xfc,0x4f,0xdb,0xc9,
    0xea,0xf4,0x34,0xa7,0xbf,0x9e,0xc5,0x87,0xd4,0x2c,0x0b,0xb1,0x41,0x40,0x55,0x31,
    0x73,0xa4,0xd8,0xf9,0xa8,0x11,0xe2,0x96,0xd3,0x1a,0x4d,0x66,0xa5,0xc2,0xe0,0x89,
    0x4a,0xbd,0xa1,0x2d,0xec,0x79,0xfb,0xef,0xad,0x5c,0xc3,0xde,0x60,0xb6,0x0c,0xe6,
    0xbb,0xce,0xcb,0x7c,0x00,0x14,0x4e,0xf5,0x8b,0xd1,0x51,0x6a,0x74,0xfa,0xd7,0xfe,
    0xf7,0x5a,0x26,0x82,0x9c,0x35,0x46,0x7e,0x25,0x53,0xae,0x59,0x21,0x3c,0xb9,0x9f,
    0x01,0x62,0x7b,0x9b,0x10,0x4b,0x8e,0x5e,0x94,0x7d,0xc8,0x5f,0xd0,0xcf,0x97,0xa9,
    0x2f,0x39,0x1b,0x67,0x2a,0x5b,0xf2,0x19,0x08,0x33,0x2e,0xb3,0x48,0xf3,0x9d,0x61,
    0x6c,0xa3,0x47,0x58,0xeb,0x28,0x91,0xba,0x1e,0x80,0xcd,0x15,0x17,0x0f,0x32,0x8f,
    0xcc,0x7a,0x5d,0x42,0xe9,0x3e,0x43,0x50,0x92,0xe8,0xe4,0xab,0x45,0x6b,0xed,0x36,
    0xb7,0x37,0x72,0x1c,0xc7,0xf6,0x84,0x8c,0x6d,0x81,0xff,0x65,0xd9,0xf0,0x13,0x0d,
    0x22,0x57,0xfd,0xc4,0xb5,0x52,0x3d,0xc0,0xd6,0x85,0x77,0x3a,0x93,0x20,0x23,0x75,
    0xa2,0x49,0x04,0x16,0x86,0xb2,0x7f,0x98,0xbc,0xe5,0x54,0x18,0x27,0xd5,0xe7,0x06,
    0x3f,0xb0,0x70,0xaa,0x8a,0x6e,0x05,0x1f,0x24,0xb8,0x90,0xf1,0x12,0xa0,0x3b,0x09
};    

static uInt8 ilwPermutation[] =
{
    0x64,0x80,0x0d,0x1e,0xe2,0xf6,0xef,0x16,0x98,0xff,0x29,0x3a,0x5e,0xcf,0x28,0xad,
    0x84,0x45,0xfc,0xce,0x65,0xab,0xe3,0xac,0xeb,0x97,0x49,0x92,0xc3,0x13,0xa8,0xf7,
    0xdd,0x7c,0xd0,0xde,0xf8,0x78,0x72,0xec,0xa5,0x12,0x94,0x2b,0x39,0x53,0x9a,0x90,
    0x04,0x3f,0xae,0x99,0x32,0x75,0xbf,0xc1,0x02,0x91,0xdb,0xfe,0x7d,0xd6,0xb5,0xf0,
    0x3d,0x3c,0xb3,0xb6,0x00,0xbc,0x76,0xa2,0x9c,0xe1,0x50,0x85,0x09,0x4a,0x66,0x2d,
    0xb7,0x6a,0xd5,0x79,0xea,0x3e,0x1b,0xd1,0xa3,0x7b,0x71,0x95,0x59,0xb2,0x87,0x8b,
    0x5c,0x9f,0x81,0x18,0x27,0xcb,0x4b,0x93,0x11,0x2a,0x6b,0xbd,0xa0,0xc8,0xf5,0x19,
    0xf2,0x1f,0xc2,0x40,0x6c,0xdf,0x03,0xda,0x21,0x55,0xb1,0x82,0x63,0x89,0x77,0xe6,
    0xa9,0xc9,0x73,0x24,0xc6,0xd9,0xe4,0x37,0x17,0x4f,0xf4,0x68,0xc7,0x07,0x86,0xaf,
    0xfa,0xa6,0xb8,0xdc,0x88,0x0a,0x47,0x8e,0xe7,0x14,0x1a,0x83,0x74,0x9e,0x35,0x7f,
    0xfd,0x52,0xe0,0xa1,0x41,0x4c,0x0b,0x33,0x44,0x8f,0xf3,0xbb,0x08,0x58,0x7a,0x0c,
    0xf1,0x3b,0xe5,0x9b,0x26,0xd4,0x5d,0xc0,0xf9,0x7e,0xa7,0x60,0xe8,0x51,0x25,0x34,
    0xd7,0x0f,0x4d,0x5a,0xd3,0x36,0x1d,0xc4,0x8a,0x2f,0x20,0x62,0xb0,0xaa,0x61,0x8d,
    0x8c,0x69,0x01,0x48,0x38,0xed,0xd8,0x6e,0x42,0xcc,0x05,0x2e,0x22,0x10,0x5b,0x06,
    0x4e,0x23,0x46,0x0e,0xba,0xe9,0x5f,0xee,0xb9,0xb4,0x30,0xa4,0x54,0xbe,0x1c,0x57,
    0xcd,0xfb,0x96,0x9d,0x31,0x67,0xc5,0x70,0x15,0x43,0x6d,0x56,0x2c,0xd2,0x6f,0xca
};


/*---------------------------- External Interface ----------------------------*/

struct stdObfuscationStateRec  {
     uInt32   seed;
     uInt32   nextMasks;
     uInt     masksLeft;
     uInt8    C;
};

#define UPDATE_MASKS(state,masksLeft,nextMasks) \
    if (--masksLeft) {                                  \
        nextMasks >>= 8;                                \
    } else {                                            \
        state->seed = state->seed * 1103515245 + 12345; \
        nextMasks   = state->seed;                      \
        masksLeft   = 4;                                \
    }


/*
 * Function         : Create new obfuscation engine from specified seed
 * Parameters       : seed         (I) Initializer for pseudo- random number
 *                                      generator hidden by this module.
 * Function Result  : New obfuscation state
 */
stdObfuscationState STD_CDECL stdCreateObfuscation( uInt32 seed )
{ 
    stdObfuscationState result;
    
    stdNEW(result);
    
    result->masksLeft =     1;
    result->seed      =  seed; 
    result->C         = ~seed; 
    
    return result;
}


/*
 * Function         : Clone specified obfuscation engine
 * Parameters       : state        (I) obfuscation state to clone
 * Function Result  : Cloned obfuscation state
 */
stdObfuscationState STD_CDECL stdCloneObfuscation( stdObfuscationState obfuscation )
{
    return (stdObfuscationState)stdCOPY(obfuscation);
}


/*
 * Function         : Delete obfuscation engine
 * Parameters       : obfuscation  (I) Obfuscation engine to delete
 */
void STD_CDECL stdDeleteObfuscation( stdObfuscationState obfuscation )
{
    stdFREE(obfuscation);
}


/*
 * Function         : Obfuscate character using specified obfuscaton state.
 * Parameters       : state        (I) obfuscation state to use
 *                    c            (I) character to obfuscate using next
 *                                     pseudo random number.
 * Function Result  : Obfuscated c.
 */
Char STD_CDECL stdObfuscate( stdObfuscationState state, Char c )
{
    UPDATE_MASKS(state,state->masksLeft,state->nextMasks);
    state->C ^= permutation[ (uInt8)(c ^ state->nextMasks) ];
    return state->C;
}


/*
 * Function         : Obfuscate character buffer using specified obfuscaton state.
 * Parameters       : state        (I) obfuscation state to use
 *                    buf          (I) character buffer to obfuscate using next
 *                                     sequence of pseudo random numbers.
 *                    size         (I) size of buffer
 * Function Result  : Obfuscated c.
 */
void STD_CDECL stdObfuscateBuffer( stdObfuscationState state, Char *buf, uInt size )
{
    uInt i;
    uInt32 nextMasks = state->nextMasks;
    uInt32 masksLft  = state->masksLeft;
    uInt8  C         = state->C;
    
    for (i=0; i<size; i++) {
        UPDATE_MASKS(state,masksLft,nextMasks);
        C ^= permutation[ (uInt8)(buf[i] ^ nextMasks) ];
        buf[i] = C;
    }
    
    state->nextMasks = nextMasks;
    state->masksLeft = masksLft;
    state->C         = C;
}


/*
 * Function         : Deobfuscate character using specified obfuscaton state.
 * Parameters       : state        (I) obfuscation state to use
 *                    c            (I) character to obfuscate using next
 *                                     pseudo random number.
 * Function Result  : Obfuscated c.
 */
Char STD_CDECL stdDeobfuscate( stdObfuscationState state, Char c )
{
    uInt8 result;

    UPDATE_MASKS(state,state->masksLeft,state->nextMasks);
    result = state->nextMasks ^ ilwPermutation[ (uInt8)(c ^ state->C) ];
    state->C = c;

    return result;
}


/*
 * Function         : Deobfuscate character buffer using specified obfuscaton state.
 * Parameters       : state        (I) obfuscation state to use
 *                    buf          (I) character buffer to obfuscate using next
 *                                     sequence of pseudo random numbers.
 *                    size         (I) size of buffer
 * Function Result  : Obfuscated c.
 */
void STD_CDECL stdDeobfuscateBuffer( stdObfuscationState state, Char *buf, uInt size )
{
    uInt   i;
    uInt8  result;
    uInt32 nextMasks = state->nextMasks;
    uInt32 masksLft  = state->masksLeft;
    uInt8  C         = state->C;
    
    for (i=0; i<size; i++) {
        UPDATE_MASKS(state,masksLft,nextMasks);
        result = nextMasks ^ ilwPermutation[ (uInt8)(buf[i] ^ C) ];
        C      = buf[i];
        buf[i] = result;
    }
    
    state->nextMasks = nextMasks;
    state->masksLeft = masksLft;
    state->C         = C;
}


